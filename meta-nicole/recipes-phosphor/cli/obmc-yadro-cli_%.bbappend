RDEPENDS_${PN}_append = " \
    obmc-yadro-backup \
    obmc-yadro-lsinventory \
    openpower-esel-parser \
    pdbg \
    phosphor-debug-collector \
    phosphor-mapper \
    phosphor-state-manager \
"

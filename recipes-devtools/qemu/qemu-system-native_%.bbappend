require qemu-yadro.inc

SRC_URI_append = "file://powerpc_rom.bin"

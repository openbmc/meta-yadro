require qemu-yadro.inc
